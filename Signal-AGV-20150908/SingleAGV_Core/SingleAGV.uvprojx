# Keil uVision project SingleAGV.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SingleAGV +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\SingleAGV_Project;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\source\user;..\source\Driver;..\source\API;..\source\APP;..\source\Modbus\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s startup_stm32f40xx.s startup_stm32f401xx.s startup_stm32f411xe.s startup_stm32f427_437xx.s startup_stm32f427x.s startup_stm32f429_439xx.s startup_stm32f446xx.s
  group User
    ../source/user/: stm32f4xx_it.c system_stm32f4xx.c main.c
  group APP
    ../source/APP/: Car.c FS.c loop.c
  group API
    ../source/API/: W25X16.c Moto_Ctrl.c Magnet_COMM.c crc.c Inside_COMM.c RGB_LED.c Voice.c outsidecomm.c
  group Driver
    ../source/Driver/: ADC1.c GPIO.c Timer.c UART1.c UART2.c UART3.c UART4.c UART6.c IWDG.c PWM.c SPI2.c
  group Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Modbus
    ../source/Modbus/: mb.c
    ../source/Modbus/ascii/: mbascii.c
    ../source/Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../source/Modbus/port/: port.c portevent.c portserial.c porttimer.c
    ../source/Modbus/rtu/: mbcrc.c mbrtu.c
    ../source/Modbus/tcp/: mbtcp.c
